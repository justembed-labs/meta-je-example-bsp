FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://je-detection.cfg"
